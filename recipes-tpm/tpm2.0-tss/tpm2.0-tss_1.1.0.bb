include ${BPN}.inc

SRC_URI = "git://github.com/01org/TPM2.0-TSS;protocol=git;tag=1.1.0_beta0;name=TPM2.0-TSS;destsuffix=TPM2.0-TSS"
