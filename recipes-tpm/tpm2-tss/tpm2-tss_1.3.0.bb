include ${BPN}.inc

SRC_URI[md5sum] = "7556894cb04c1a9b1525ad601b2c536d"
SRC_URI[sha256sum] = "c7d627de50394e9a02593edb1ce74e1bbac17831be726c54f689507f0c41a78a"
SRC_URI = "https://github.com/tpm2-software/${BPN}/releases/download/${PV}/${BPN}-${PV}.tar.gz"
