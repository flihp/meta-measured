include ${BPN}.inc

SRC_URI[md5sum] = "3fadb8ee8a4e506b9732d2a9dfcad77c"
SRC_URI[sha256sum] = "cf8784cc536be16e6fba47f77033e093a6aeaed8420877ac9f42f77fb7b09031"
