include ${BPN}.inc

SRC_URI = "git://github.com/01org/${BPN}.git;protocol=git;tag=${PV};name=${BPN};destsuffix=${BPN}"
