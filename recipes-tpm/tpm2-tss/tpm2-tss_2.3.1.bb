include ${BPN}.inc

SRC_URI[md5sum] = "5744b10e3cef56df5d65b50f51fb3fe9"
SRC_URI[sha256sum] = "7096576c1946b85ec9c92b39e0ed3409ec01bdb97d7863ead033243d5433dee7"
