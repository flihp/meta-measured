include tpm2.0-tools.inc

SRC_URI[md5sum] = "115b0f10abe35dd65ce40ad8a9e6a43f"
SRC_URI[sha256sum] = "01c45de006011db1cc91df11043102cc23fd0d7dda9dc4a9b6ea453bec4c4b3d"
SRC_URI += "file://gcc7.diff"
