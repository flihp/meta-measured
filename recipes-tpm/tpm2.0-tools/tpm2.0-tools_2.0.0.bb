include tpm2.0-tools.inc

SRC_URI = "git://github.com/01org/tpm2.0-tools.git;protocol=git;tag=2.0.0;name=tpm2.0-tools;destsuffix=tpm2.0-tools"
