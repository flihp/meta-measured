# 0.3.14 unpacks to the current directory instead of to a sub-directory

S = "${WORKDIR}"

require trousers.inc

SRC_URI[md5sum] = "4a476b4f036dd20a764fb54fc24edbec"
SRC_URI[sha256sum] = "ce50713a261d14b735ec9ccd97609f0ad5ce69540af560e8c3ce9eb5f2d28f47"
