include ${BPN}.inc

SRC_URI += "git://github.com/01org/tpm2-abrmd;protocol=git;tag=1.0.0;name=tpm2-abrmd;destsuffix=tpm2-abrmd"
