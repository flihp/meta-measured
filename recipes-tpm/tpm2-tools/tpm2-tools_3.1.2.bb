include tpm2-tools.inc

SRC_URI[md5sum] = "aa8e0f61608bd02a2b0082dafceddb60"
SRC_URI[sha256sum] = "80136c2b247b4d8cdd34b70960622ba22126150a286e49f3e77cda5fcef36294"
