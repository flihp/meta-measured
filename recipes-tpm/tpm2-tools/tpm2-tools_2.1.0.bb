include tpm2-tools.inc

SRCREV = "27d34a61cb947780ab58508dfea70e696cff185c"
SRC_URI += " \
    file://gcc7.diff \
"
