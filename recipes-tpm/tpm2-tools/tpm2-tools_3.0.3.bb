include tpm2-tools.inc

SRC_URI[md5sum] = "9c44eb0308d5bf23a02ad08b63cd37db"
SRC_URI[sha256sum] = "c990c0656165afef0fad61e1852a9a189a4b93b43d2a684b151a5dc0b3c6249d"
