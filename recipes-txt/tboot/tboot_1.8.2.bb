include tboot.inc

SRC_URI[md5sum] = "4849a56f1d8db1ec41b6b117e1931b43"
SRC_URI[sha256sum] = "358c7b22412087927d6d04b130c1268e5d00252b4caef0fe3cdaa5194f652cd1"
