include tboot.inc

SRC_URI[md5sum] = "6c61f4db468cf50baf7adbeaac1231e7"
SRC_URI[sha256sum] = "2f2e0c3865b45691f76b31730c5aaea2f076e7949ee6309e78ed7f80d8c53d39"
