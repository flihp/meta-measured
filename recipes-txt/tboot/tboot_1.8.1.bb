include tboot.inc

SRC_URI[md5sum] = "b471f3230cddb33b458020dc7b88810c"
SRC_URI[sha256sum] = "8007c868c33ac4764d6477febcff5f829c6598b3cf8c8cf97aa3b06c7802a3aa"
