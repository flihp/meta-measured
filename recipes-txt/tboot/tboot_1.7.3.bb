include tboot.inc

SRC_URI[md5sum] = "bc7ec3bdd71b21fb73368f24bf697739"
SRC_URI[sha256sum] = "ed8aa461e4eba6c02dd6f8ee6d44195ec634d45fa16dc386c70cd0d7ab9d6b0d"
