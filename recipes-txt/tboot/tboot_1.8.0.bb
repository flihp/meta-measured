include tboot.inc

SRC_URI[md5sum] = "a54e9e070e81f578048c7b85979a8a87"
SRC_URI[sha256sum] = "b90bdeb60fb4e522791fa4ac6572a7e6745a6fc6d6b33c1c09275becb3aae113"
