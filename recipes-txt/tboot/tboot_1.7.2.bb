include tboot.inc

SRC_URI[md5sum] = "c8f981e5ee0a36a033e96383835c603b"
SRC_URI[sha256sum] = "e0ed44d7ff7d2fa018fbf7cb9dccfaee47269d9a9f4a4688824aaa32353ab323"
