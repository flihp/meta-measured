include tboot.inc

SRC_URI[md5sum] = "bf785aa8637846f4c741d436146227fa"
SRC_URI[sha256sum] = "1b55eed6ca8196b2a003936594248a242888ac34ff970eda651e7660c4772a39"
