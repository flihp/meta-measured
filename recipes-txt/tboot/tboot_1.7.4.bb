include tboot.inc

SRC_URI[md5sum] = "d0a231d6f4ff710cfa9f55b3ad4d8398"
SRC_URI[sha256sum] = "478c68ddd59910496d6ade1670840d9ce6721befbc83cfb280efdb233838a947"
