include tboot.inc

SRC_URI[md5sum] = "74332176ae61a02ff145a7e70c8a8584"
SRC_URI[sha256sum] = "03879712edbf42e82c586fb2c9dfa26c1b6fa885cb0c935dcf3caed8294bd798"
