include tboot.inc

SRC_URI[md5sum] = "5454cae3bf4c4ba47e7dac14ea3088b4"
SRC_URI[sha256sum] = "d6f2334ae41b90e8403a2cd91a819d54356edcb81af2924f47774c72e48d3a9e"
