require recipes-kernel/linux/linux-yocto-measured.inc
