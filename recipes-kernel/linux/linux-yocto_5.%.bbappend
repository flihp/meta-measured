require linux-yocto-measured.inc
